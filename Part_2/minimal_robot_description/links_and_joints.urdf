Commit message: edit offset consistent w text

File: Part_2/minimal_robot_description/links_and_joints.urdf (robot description, URDF)
Before this commit: robot one_DOF_robot, 2 links, 1 joints
Joints:
- joint joint1: origin xyz=0 0 0.5 rpy=0 0 0 -> xyz=0 0 1 rpy=0 0 0
